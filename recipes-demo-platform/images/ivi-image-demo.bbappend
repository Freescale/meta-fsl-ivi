IMAGE_INSTALL_append = " \
    packagegroup-fslc-gstreamer1.0-full \
    "
